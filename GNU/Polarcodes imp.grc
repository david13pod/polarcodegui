options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: List_n
  id: variable
  parameters:
    value: '4'
  states: {}
- name: activate_RM
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: channel
  id: variable
  parameters:
    value: '''ucl'''
  states: {}
- name: msg_len
  id: variable
  parameters:
    value: '30'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: rate
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    label: EbNo_dB
    start: '0'
    step: '0.5'
    stop: '20'
    value: '4'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_encoder_bc_1
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from polarcodes import *
      from polarcodes import Sim_utils
      import pprint
      import time
      import pmt


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,msg_len=1,use_RM=True,rate=1,channel='ucl'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Polar Encoder',   # will show up in GRC
                  in_sig=[np.int8],
                  # in_sig=None,
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msg_len=msg_len
              self.rate=rate
              self.useRM= use_RM
              self.channel=channel

          # def forecast(self, noutput_items, ninput_items_required):
          #     #setup size of input_items[i] for work call
          #     print("---------- Forecast function --------------")
          #     n_in1 = noutput_items
          #     print("noutput_items : ", type(ninput_items_required))
          #     n_in2 = self.msg_len
          #     # print(n_in1,"n_in : ",  n_in2)
          #     ninput_items_required[0]=20
          #     # ninput_items_required[1]=n_in2
          #     print("ninput_items_required[0] : ", ninput_items_required)
          #     # # print("noutput_items : ", noutput_items)
          def forecast(self, noutput_items, ninputs):
              """
              forecast is only called from a general block
              this is the default implementation
              """
              # print("---------- Forecast function --------------")
              # print("ooo_items : ", noutput_items)
              # ninput_items_required = [0]*ninputs
              ninput_items_required = [0]*ninputs
              ninput_items_required[0] = 10
              # print("ninput_itemsreq : ", ninput_items_required)
              # for i in range(ninputs):
              #     ninput_items_required[i] = 200
              # print("ninput_itemsreq : ", ninput_items_required)
              # time.sleep(1)
              return ninput_items_required
          
          # noutput_items=200
          # ninput_items=200
          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              # self.forecast(1,1)
              # print('2',len(output_items[0]))
              # print('2',len(input_items[0]))
              # print((input_items[0].dtype))
              # pprint.pprint((input_items[0]))
              # pprint.pprint((input_items[1]))
              msg_len=[self.msg_len] # information length
              # crc_n=Sim_utils.crc_selector(msg_len,'ucl') # crc polynomial generator length
              crc_n=Sim_utils.crc_selector(msg_len,self.channel) # crc polynomial generator length
              k=list(crc_n+np.array(msg_len))
              M=(np.array(msg_len)/np.array(self.rate))  #codeword E = A/R
              M=list(M.astype(int))
              self.M=M
              N = Sim_utils.mothercode(self.channel,k,M)
              if self.useRM == False:
                  M=N  # no rate matching M == N
              # print(1)
              match_rate=list(np.array(k)/np.array(M))# K/E
              # rate=list(np.array(msg_len)/np.array(M)) # A/E
              construction='5g' # construction type
              # sim_time=10000 # number of blocks
              useRM=self.useRM
              snr=1
              # time.sleep(5)
              # print(2)
              # print(N,M,k,match_rate,useRM)
              for i in range(0,len(msg_len)):
                  # time.sleep(2)
                  # print(1)
                  myPC=Sim_utils.matching_scheme_selector(N[i],M[i],k[i],match_rate[i],useRM,snr,construction)
                  # print(2)
                  # pprint.pprint((input_items[0]))
                  crc_coded = input_items[0][:k[i]]
                  # print('crc', crc_coded)
                  myPC.x[myPC.frozen_lookup == 1] = crc_coded
                  myPC.u = myPC.x.copy()
                  # print('bf enc',myPC.u)
                  # print(3)

                  # print(myPC.u)
                  Encode(myPC)

                  myPC.tx = myPC.u # No rate matching used
                  # print('enc', myPC.tx)
                  # print(myPC.punct_flag)
                  # print(myPC.frozen)
                  # print(msg_len,' ',len(myPC.u))
                  # output_items[0] = np.ones(256,dtype=np.int0)
                  # self.consume(0, M[i]) #consume port 1 input
                  output_items[0][:N[i]] = myPC.tx.astype(np.int8)
                  # print('3',len(output_items[0][:N[i]]))
                  # print('4',(output_items[0][:N[i]]))
                  # time.sleep(5)
                  self.consume(0, len(input_items[0])) #consume port 0 input
                  # self.consume(1, N[i]) #consume port 1 input
                  
              return len(output_items[0][:N[i]])
              # return len(input_items[0])
    channel: channel
    msg_len: msg_len
    rate: rate
    use_RM: activate_RM
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from polarcodes import *
      from polarcodes import Sim_utils
      import pprint
      import time
      import pmt


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,msg_len=1,rate=1,use_RM=True,channel='ucl'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Message generator',   # will show up in GRC
                  # in_sig=[np.int8],
                  in_sig=None,
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msg_len=msg_len
              self.rate=rate
              self.useRM= use_RM
              self.channel=channel

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              # print(len(input_items[0]))
              # print((input_items[0].dtype))
              # pprint.pprint((input_items[0]))
              # print(self.msg_len)

              time.sleep(5)
              msg_len=[self.msg_len] # message length

              crc_n=Sim_utils.crc_selector(msg_len,self.channel) # crc polynomial generator length
              k=list(crc_n+np.array(msg_len))
              M=(np.array(msg_len)/np.array(self.rate))  #codeword E = A/R
              self.M=list(M.astype(int))
              N = Sim_utils.mothercode(self.channel,k,M)
              if self.useRM == False:
                  self.M=N  # no rate matching M == N
             

              for i in range(0,len(msg_len)):
                  my_message = np.random.randint(2, size=msg_len[i],dtype=np.int8)
                  zobo = np.zeros(self.M[i])
                  
                  with open('sim6msg.txt','a') as f:
                      f.write(f'{list(my_message)},{N[i]},{self.M[i]},{self.rate}.\n')
                      f.close()

                  output_items[0][:self.M[i]] = zobo
                  output_items[0][:msg_len[i]] = my_message.astype(np.int8)
              
              print((output_items[0][:msg_len[0]]))
              # print((self.M[0]))
              # print((output_items[0][:msg_len]))
              # self.produce(0, msg_len) #consume port 0 input
              
                  
              return len(output_items[0][:self.M[0]])
              # return
    channel: channel
    msg_len: msg_len
    rate: rate
    use_RM: activate_RM
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from polarcodes import *
      from polarcodes import Sim_utils
      import pprint
      import time
      import pmt


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,msg_len=1,use_RM=True,rate=1,channel='ucl'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='CRC Encoder',   # will show up in GRC
                  in_sig=[np.int8],
                  # in_sig=None,
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msg_len=msg_len
              self.rate=rate
              self.useRM= use_RM
              self.channel=channel

          def forecast(self, noutput_items, ninputs):
              """
              forecast is only called from a general block
              this is the default implementation
              """
              # print("---------- Forecast function --------------")
              # print("ooo_items : ", noutput_items)
              # ninput_items_required = [0]*ninputs
              ninput_items_required = [0]*ninputs
              ninput_items_required[0] = 10
              # print("ninput_itemsreq : ", ninput_items_required)
              # for i in range(ninputs):
              #     ninput_items_required[i] = 200
              # print("ninput_itemsreq : ", ninput_items_required)
              # time.sleep(1)
              return ninput_items_required
          
          # noutput_items=200
          # ninput_items=200
          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              # self.forecast(1,1)
              # print('2',len(output_items[0]))
              # print(len(input_items[0]))
              # print((input_items[0].dtype))
              # pprint.pprint((input_items[0]))
              # pprint.pprint((input_items[1]))
              msg_len=[self.msg_len] # information length
              # crc_n=Sim_utils.crc_selector(msg_len,'ucl') # crc polynomial generator length
              crc_n=Sim_utils.crc_selector(msg_len,self.channel) # crc polynomial generator length
              k=list(crc_n+np.array(msg_len))
              M=(np.array(msg_len)/np.array(self.rate))  #codeword E = A/R
              M=list(M.astype(int))
              self.M=M
              N = Sim_utils.mothercode(self.channel,k,M)
              if self.useRM == False:
                  M=N  # no rate matching M == N
              # print(1)
              match_rate=list(np.array(k)/np.array(M)) # K/E
              # rate=list(np.array(msg_len)/np.array(M)) # A/E
              construction='5g' # construction type
              # sim_time=10000 # number of blocks
              useRM=self.useRM
              snr=1
              # time.sleep(5)
              # print(2)
              for i in range(0,len(msg_len)):
                  # time.sleep(2)
                  myPC=Sim_utils.matching_scheme_selector(N[i],M[i],k[i],match_rate[i],useRM,snr,construction)
                  # print(msg_len[i])
                  # pprint.pprint((input_items[0]))
                  my_message = input_items[0][:msg_len[i]]
                  # print(my_message)
                  myPC.set_message(my_message,crc_n[i])
                  crc_coded=myPC.crc_coded
                  # print(myPC.punct_flag)
                  # print(myPC.frozen)
                  # print(msg_len,' ',len(crc_coded))

                  # crc encoded msg
                  zobo = np.zeros(M[i])
                  output_items[0][:M[i]] = zobo
                  output_items[0][:k[i]] = crc_coded.astype(np.int8)
                  # print('3',len(output_items[0][:M[i]]))
                  # print('4',(output_items[0][:k[i]]))
                  # time.sleep(5)
                  self.consume(0, len(input_items[0])) #consume port 0 input
                  # self.consume(1, N[i]) #consume port 1 input
                  
              return len(output_items[0][:M[i]])
              # return len(input_items[0])
    channel: channel
    msg_len: msg_len
    rate: rate
    use_RM: activate_RM
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from tkinter.constants import S
      import numpy as np
      from gnuradio import gr
      from polarcodes import *
      from polarcodes import Sim_utils
      import pprint
      import time
      import pmt


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,msg_len=1,use_RM=True,rate=1,channel='ucl',snr=5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Noise',   # will show up in GRC
                  in_sig=[np.complex64],
                  # in_sig=None,
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msg_len=msg_len
              self.rate=rate
              self.useRM= use_RM
              self.channel=channel
              self.snr=snr

          def forecast(self, noutput_items, ninputs):
              """
              forecast is only called from a general block
              this is the default implementation
              """
              # print("---------- Forecast function --------------")
              # print("ooo_items : ", noutput_items)
              # ninput_items_required = [0]*ninputs
              ninput_items_required = [0]*ninputs
              ninput_items_required[0] = 10
              # print("ninput_itemsreq : ", ninput_items_required)
              # for i in range(ninputs):
              #     ninput_items_required[i] = 200
              # print("ninput_itemsreq : ", ninput_items_required)
              # time.sleep(1)
              return ninput_items_required
          
          # noutput_items=200
          # ninput_items=200
          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              # self.forecast(1,1)
              # print('1',len(output_items[0]))
              # print('tx',len(input_items[0]))
              # print((input_items[0].dtype))
              # pprint.pprint((input_items[0]))
              # pprint.pprint((input_items[1]))
              msg_len=[self.msg_len] # information length
              # crc_n=Sim_utils.crc_selector(msg_len,'ucl') # crc polynomial generator length
              crc_n=Sim_utils.crc_selector(msg_len,self.channel) # crc polynomial generator length
              k=list(crc_n+np.array(msg_len))
              M=(np.array(msg_len)/np.array(self.rate))  #codeword E = A/R
              M=list(M.astype(int))
              self.M=M
              N = Sim_utils.mothercode(self.channel,k,M)
              if self.useRM == False:
                  M=N  # no rate matching M == N
              # print(1)
              snr=self.snr
              # time.sleep(5)
              # print(2)
              for i in range(0,len(msg_len)):
                  # time.sleep(2)
                  # print(2)
                  tx_len = len(input_items[0])
                  tx=input_items[0]
                  Linear_EbNo=10**(-snr/10)
                  noise = np.random.normal(0, np.sqrt(2*Linear_EbNo)/2, size=(tx_len,2)).view(np.complex128)
                  noise= noise.flatten()
                  rx=tx+noise

                  output_items[0][:tx_len] = rx
                  print('3',len(output_items[0][:tx_len]))
                  # print('4',(output_items[0][:k[i]]))
                  # time.sleep(5)
                  self.consume(0, len(input_items[0])) #consume port 0 input
                  # self.consume(1, N[i]) #consume port 1 input
                  
              return len(output_items[0][:tx_len])
              # return len(input_items[0])
    channel: channel
    msg_len: msg_len
    rate: rate
    snr: snr
    use_RM: activate_RM
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from polarcodes import *
      from polarcodes import Sim_utils
      import pprint
      import time
      import pmt



      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,msg_len=1,use_RM=True,rate=1,channel='ucl',snr=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Rate_dematcher',   # will show up in GRC
                  in_sig=[np.int8],
                  # in_sig=[np.float32],
                  # in_sig=None,
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msg_len=msg_len
              self.rate=rate
              self.useRM= use_RM
              self.channel=channel
              self.snr=snr

          # def forecast(self, noutput_items, ninput_items_required):
          #     #setup size of input_items[i] for work call
          #     print("---------- Forecast function --------------")
          #     n_in1 = self.N
          #     print("noutput_items : ", type(ninput_items_required))
          #     n_in2 = self.msg_len
          #     # print(n_in1,"n_in : ",  n_in2)
          #     ninput_items_required. =[1]
          #     # ninput_items_required[1]=n_in2
          #     # print("ninput_items_required[0] : ", ninput_items_required[0])
          #     # # print("noutput_items : ", noutput_items)
          def forecast(self, noutput_items, ninputs):
              """
              forecast is only called from a general block
              this is the default implementation
              """
              # print("---------- Forecast function --------------")
              # print("ooo_items : ", noutput_items)
              # ninput_items_required = [0]*ninputs
              ninput_items_required = [0]*ninputs
              ninput_items_required[0] = 10
              # time.sleep(1)
              return ninput_items_required
          

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              time.sleep(1)
              print('2',len(input_items[0]))
              # print(len(input_items[1]))
              # print((input_items[0].dtype))
              # pprint.pprint((input_items[0]))
              # pprint.pprint((input_items[1]))
              msg_len=[self.msg_len] # information length
              # crc_n=Sim_utils.crc_selector(msg_len,'ucl') # crc polynomial generator length
              crc_n=Sim_utils.crc_selector(msg_len,self.channel) # crc polynomial generator length
              k=list(crc_n+np.array(msg_len))
              M=(np.array(msg_len)/np.array(self.rate))  #codeword E = A/R
              M=list(M.astype(int))
              self.M=M
              N = Sim_utils.mothercode(self.channel,k,M)
              if self.useRM == False:
                  M=N  # no rate matching M == N
              # print(1)
              match_rate=list(np.array(k)/np.array(M)) # K/E
              # rate=list(np.array(msg_len)/np.array(M)) # A/E
              construction='5g' # construction type
              # sim_time=10000 # number of blocks
              useRM=self.useRM
              snr=self.snr
              # time.sleep(5)
              # print(2)
                  

              # def get_likelihoods(y):
              #     Linear_EbNo=10**(snr/10)
              #     for i in range(len(y)):
              #         # s = np.random.normal(0, np.sqrt( (2*Linear_EbNo)), size=1)
              #         # print(s)
              #         # y[i]=2 * (y[i] - 0.5)*np.sqrt(Linear_EbNo) 
              #         # y[i]=1-(2 * y[i] * np.sqrt(Linear_EbNo) )
              #         y[i]=(1-(2 * y[i]))
              #     return y

              for i in range(0,len(msg_len)):
                  # time.sleep(2)
                  # print(11)
                  myPC=Sim_utils.matching_scheme_selector(N[i],self.M[i],k[i],match_rate[i],useRM,snr,construction)
                  # print(myPC.frozen)

                  # myPC.tx = self.modulation(self.myPC.u)
                  # print(myPC.punct_flag)
                  # if myPC.punct_flag:
                  #     # punctured bit not meant to be sent over the channel
                  #     if myPC.punct_type == 'shorten':  #shortening procedure
                  #         myPC.rx = input_items[0]
                  #         myPC.likelihoods = np.concatenate((np.array(get_likelihoods(myPC.rx), dtype=np.float64),
                  #             np.zeros(myPC.s,dtype=np.float64)))
                  #         myPC.likelihoods[myPC.source_set_lookup == 0] = np.inf
                  #     elif myPC.punct_type == 'punct':  #puncturing procedure
                  #         myPC.rx = input_items[0]
                  #         myPC.likelihoods = np.concatenate((np.zeros(myPC.s,dtype=np.float64),
                  #             np.array(get_likelihoods(myPC.rx), dtype=np.float64)))
                  #         myPC.likelihoods[myPC.source_set_lookup == 0] = 0
                  #     elif myPC.punct_type == 'rep':   #repetition procedure
                  #         myPC.rx = input_items[0]
                  #         rep_remover=myPC.rx[0:myPC.N]
                  #         for j in range(myPC.N,myPC.M):
                  #             index = (j% myPC.N)
                  #             rep_remover[index] = rep_remover[index]  + myPC.rx[j]
                  #         myPC.rx=rep_remover
                  #         myPC.likelihoods = np.array(get_likelihoods(myPC.rx), dtype=np.float64)
                          
                  # else:
                  #     myPC.rx = input_items[0]
                  #     myPC.likelihoods = np.array(get_likelihoods(myPC.rx), dtype=np.float64)

                  myPC.rx = input_items[0]
                  AWGN(myPC, snr)


                  # print(5)
                  # print(msg_len,' ',len(myPC.u))
                  # output_items[0] = np.ones(256,dtype=np.int0)
                  output_items[0][:N[i]] = myPC.likelihoods.astype(np.float64)
                  # print('6',len(output_items[0][:N[i]]))
                  # print(('6',(output_items[0][:N[i]])))
                  # time.sleep(5)
                  self.consume(0, len(input_items[0])) #consume port 0 input
                  # self.consume(1, N[i]) #consume port 1 input
                  
              return len(output_items[0][:N[i]])
              # return len(input_items[0])
    channel: channel
    msg_len: msg_len
    rate: rate
    snr: snr
    use_RM: activate_RM
  states: {}
- name: epy_block_0_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from polarcodes import *
      from polarcodes import Sim_utils
      import pprint
      import time
      import pmt


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,msg_len=1,use_RM=True,rate=1,channel='ucl',list_n=4,snr=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Polar Decoder',   # will show up in GRC
                  in_sig=[np.float32],
                  # in_sig=[np.float32],
                  # in_sig=None,
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msg_len=msg_len
              self.rate=rate
              self.useRM= use_RM
              self.channel=channel
              self.list_n=list_n
              self.snr=snr

          # def forecast(self, noutput_items, ninput_items_required):
          #     #setup size of input_items[i] for work call
          #     print("---------- Forecast function --------------")
          #     n_in1 = self.N
          #     print("noutput_items : ", type(ninput_items_required))
          #     n_in2 = self.msg_len
          #     # print(n_in1,"n_in : ",  n_in2)
          #     ninput_items_required. =[1]
          #     # ninput_items_required[1]=n_in2
          #     # print("ninput_items_required[0] : ", ninput_items_required[0])
          #     # # print("noutput_items : ", noutput_items)
          def forecast(self, noutput_items, ninputs):
              """
              forecast is only called from a general block
              this is the default implementation
              """
              # print("---------- Forecast function --------------")
              # print("ooo_items : ", noutput_items)
              # ninput_items_required = [0]*ninputs
              ninput_items_required = [0]*ninputs
              ninput_items_required[0] = 10
              # time.sleep(1)
              return ninput_items_required
          

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              time.sleep(1)
              # print('7',len(input_items[0]))
              # print(len(input_items[1]))
              # print((input_items[0].dtype))
              # pprint.pprint((input_items[0]))
              # pprint.pprint((input_items[1]))
              msg_len=[self.msg_len] # information length
              # crc_n=Sim_utils.crc_selector(msg_len,'ucl') # crc polynomial generator length
              crc_n=Sim_utils.crc_selector(msg_len,self.channel) # crc polynomial generator length
              k=list(crc_n+np.array(msg_len))
              M=(np.array(msg_len)/np.array(self.rate))  #codeword E = A/R
              M=list(M.astype(int))
              self.M=M
              N = Sim_utils.mothercode(self.channel,k,M)
              if self.useRM == False:
                  M=N  # no rate matching M == N
              # print(1)
              match_rate=list(np.array(k)/np.array(M)) # K/E
              # rate=list(np.array(msg_len)/np.array(M)) # A/E
              construction='5g' # construction type
              # sim_time=10000 # number of blocks
              useRM=self.useRM
              snr=self.snr
              # time.sleep(5)
              # print(2)
              for i in range(0,len(msg_len)):
                  # time.sleep(2)
                  # print(np.inf-np.inf)
                  myPC=Sim_utils.matching_scheme_selector(N[i],self.M[i],k[i],match_rate[i],useRM,snr,construction)
                  # print(myPC.frozen)

                  # initiate crc decoder parameters
                  dummy=np.random.randint(2, size=msg_len,dtype=np.int8)
                  myPC.crc_encode=CRC(dummy,crc_n[i])

                  # get decoder input
                  myPC.likelihoods=input_items[0]
                  myPC.likelihoods=np.array(myPC.likelihoods,dtype=np.float64)
                  # pprint.pprint(myPC.likelihoods)

                  # Decode
                  # Decode(myPC) #to use scd decoder
                  Decode(myPC, list=self.list_n, decoder_name ='SCL')
                  
                  message_received=np.array(myPC.message_received,dtype=np.float32)
                  rx_msg=np.array(myPC.message_received,dtype=np.int8)
                  with open('sim6dcdmdg.txt','a') as f:
                      f.write(f'{snr},{list(rx_msg)}\n')
                      f.close()

                  print('msg ',message_received)
                  
                  
                  # print(msg_len,' ',len(myPC.u))
                  # output_items[0] = np.ones(256,dtype=np.int0)
                  output_items[0][:msg_len[i]] = message_received
                  # print('8',(output_items[0][:msg_len[i]]))
                  # print('7',(output_items[0][:N[i]]))
                  # time.sleep(5)
                  self.consume(0, len(input_items[0])) #consume port 0 input
                  # self.consume(1, N[i]) #consume port 1 input
                  
              return len(output_items[0][:msg_len[i]])
              # return len(input_items[0])
    channel: channel
    list_n: List_n
    msg_len: msg_len
    rate: rate
    snr: snr
    use_RM: activate_RM
  states: {}
- name: epy_block_0_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from polarcodes import *
      from polarcodes import Sim_utils
      import pprint
      import time
      import pmt


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,msg_len=1,use_RM=True,rate=1,channel='ucl'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Rate Matcher',   # will show up in GRC
                  in_sig=[np.int8],
                  # in_sig=None,
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msg_len=msg_len
              self.rate=rate
              self.useRM= use_RM
              self.channel=channel

          # def forecast(self, noutput_items, ninput_items_required):
          #     #setup size of input_items[i] for work call
          #     print("---------- Forecast function --------------")
          #     n_in1 = noutput_items
          #     print("noutput_items : ", type(ninput_items_required))
          #     n_in2 = self.msg_len
          #     # print(n_in1,"n_in : ",  n_in2)
          #     ninput_items_required[0]=20
          #     # ninput_items_required[1]=n_in2
          #     print("ninput_items_required[0] : ", ninput_items_required)
          #     # # print("noutput_items : ", noutput_items)
          def forecast(self, noutput_items, ninputs):
              """
              forecast is only called from a general block
              this is the default implementation
              """
              # print("---------- Forecast function --------------")
              # print("ooo_items : ", noutput_items)
              # ninput_items_required = [0]*ninputs
              ninput_items_required = [0]*ninputs
              ninput_items_required[0] = 10
              # print("ninput_itemsreq : ", ninput_items_required)
              # for i in range(ninputs):
              #     ninput_items_required[i] = 200
              # print("ninput_itemsreq : ", ninput_items_required)
              # time.sleep(1)
              return ninput_items_required
          
          # noutput_items=200
          # ninput_items=200
          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              # self.forecast(1,1)
              # print('2',len(output_items[0]))
              # print('7',len(input_items[0]))
              # print((input_items[0].dtype))
              # pprint.pprint((input_items[0]))
              # pprint.pprint((input_items[1]))
              msg_len=[self.msg_len] # information length
              # crc_n=Sim_utils.crc_selector(msg_len,'ucl') # crc polynomial generator length
              crc_n=Sim_utils.crc_selector(msg_len,self.channel) # crc polynomial generator length
              k=list(crc_n+np.array(msg_len))
              M=(np.array(msg_len)/np.array(self.rate))  #codeword E = A/R
              M=list(M.astype(int))
              self.M=M
              N = Sim_utils.mothercode(self.channel,k,M)
              if self.useRM == False:
                  M=N  # no rate matching M == N
              # print(1)
              match_rate=list(np.array(k)/np.array(M)) # K/E
              # rate=list(np.array(msg_len)/np.array(M)) # A/E
              construction='5g' # construction type
              # sim_time=10000 # number of blocks
              useRM=self.useRM
              snr=1
              # time.sleep(5)
              # print(2)
              # print(N,M,k,match_rate,useRM)
              for i in range(0,len(msg_len)):
                  # time.sleep(2)
                  # print(1)
                  myPC=Sim_utils.matching_scheme_selector(N[i],self.M[i],k[i],match_rate[i],useRM,snr,construction)
                  # print(2)
                  # pprint.pprint((input_items[0]))
                  myPC.tx = input_items[0][:N[i]]
                  # print('rm', myPC.tx)
                  
                  # Rate matching
                  myPC.tx = myPC.tx # No rate matching used
                  # print(myPC.tx)
                  if myPC.punct_flag:
                      # punctured bit not meant to be sent over the channel
                      if myPC.punct_type == 'shorten':  #shortening procedure
                          myPC.tx = myPC.tx[0:myPC.M]
                      elif myPC.punct_type == 'punct':  #puncturing procedure
                          myPC.tx = myPC.tx[myPC.s:myPC.N]
                      elif myPC.punct_type == 'rep':   #repetition procedure
                          match_position= np.array(range(0,myPC.M))% myPC.N 
                          myPC.tx=myPC.tx[match_position]

                  # print(myPC.punct_flag)
                  # print(myPC.frozen)
                  # print(msg_len,' ',len(myPC.u))
                  # output_items[0] = np.ones(256,dtype=np.int0)
                  # self.consume(0, M[i]) #consume port 1 input
                  output_items[0][:M[i]] = myPC.tx.astype(np.int8)
                  # print('5',len(output_items[0][:M[i]]))
                  # print('6',(output_items[0][:M[i]]))
                  # time.sleep(5)
                  self.consume(0, len(input_items[0])) #consume port 0 input
                  # self.consume(1, N[i]) #consume port 1 input
                  
              return len(output_items[0][:M[i]])
              # return len(input_items[0])
    channel: channel
    msg_len: msg_len
    rate: rate
    use_RM: activate_RM
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: After Mod
    size: '100'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: Input msg
    name: Input message
    size: msg_len
    srate: '50'
    type: float
    update_time: '0.050'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: red
    entags: 'False'
    grid: 'True'
    label1: decoded msg
    name: Polar codes Decoded message
    size: msg_len
    srate: '50'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 20e6
    center_freq0: 2.4e9
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 20e6
    center_freq0: 2.4e9
    gain0: '1'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_1, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_throttle_0, '0', epy_block_0_1_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', epy_block_0_2, '0']
- [digital_constellation_encoder_bc_1, '0', blocks_throttle_0, '0']
- [digital_constellation_encoder_bc_1, '0', qtgui_const_sink_x_0_0, '0']
- [epy_block_0, '0', epy_block_0_3, '0']
- [epy_block_0_0, '0', blocks_char_to_float_0_1, '0']
- [epy_block_0_0, '0', epy_block_0_1, '0']
- [epy_block_0_1, '0', epy_block_0, '0']
- [epy_block_0_1_0, '0', digital_constellation_decoder_cb_0, '0']
- [epy_block_0_2, '0', epy_block_0_2_0, '0']
- [epy_block_0_2_0, '0', blocks_delay_0_0, '0']
- [epy_block_0_3, '0', digital_constellation_encoder_bc_1, '0']
- [uhd_usrp_source_0, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
